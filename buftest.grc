options:
  parameters:
    generate_options: no_gui
    id: buftest
    output_language: python
    title: buf-test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '10'
    low_cutoff_freq: '5'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_throttle_0, '0']
- [band_pass_filter_0, '0', blocks_null_sink_0, '0']
- [blocks_throttle_0, '0', band_pass_filter_0, '0']

metadata:
  file_format: 1
